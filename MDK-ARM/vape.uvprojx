# Keil uVision project vape.uvprojx, settings and files
target vape (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: vape +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --C99
  c include: ../Inc;                             ../Drivers/STM32F1xx_HAL_Driver/Inc;                             ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                             ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;                             ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: stm32f1xx_it.c main.c stm32f1xx_hal_msp.c fonts.c ssd1306.c vape.c eeprom.c fonts3.c
    ../Inc/: fonts.h main.h ssd1306.h vape.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_adc.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_i2c.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_dma.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
software components: CMSIS:CORE 5.0.2
